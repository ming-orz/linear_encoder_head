# Keil uVision project linearEncoderHead.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: linearEncoderHead +hex
  group Source Group 1
    ./: MAIN.C isr.asm table.c oled.c
  group lib
    ./library/: STC32G_Clock.c STC32G_Delay.c STC32G_NVIC.c STC32G_PWM.c STC32G_PWM_Isr.c STC32_MDU32_V1.1.LIB stc_usb_cdc_32g.LIB
